options:
  parameters:
    author: sfriedman
    copyright: TapHere!
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: SABR GNURadio FM Demo
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '70000000'
    step: '100000'
    stop: '6000000000'
    value: '106700000'
    widget: counter
  states: {}
- name: gain_mode
  id: variable_qtgui_chooser
  parameters:
    label: Gain Mode
    label0: Manual Gain
    label1: Slow AGC
    label2: Fast AGC
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: radio_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '-10'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["640000", "960000", "1000000", "1920000", "2000000", "3840000", "4000000", "6000000", "7680000", "8000000", "10000000", "14000000", "15360000", "16000000", "20000000", "24000000", "28000000", "30720000", "32000000", "36000000", "40000000", "44000000", "48000000", "52000000", "56000000", "60000000", "61440000"]'
    num_opts: '0'
    options: '[640000, 960000, 1000000, 1920000, 2000000, 3840000, 4000000, 6000000, 7680000, 8000000, 10000000, 14000000, 15360000, 16000000, 20000000, 24000000, 28000000, 30720000, 32000000, 36000000, 40000000, 44000000, 48000000, 52000000, 56000000, 60000000, 61440000]'
    orient: Qt.QHBoxLayout
    type: real
    value: '7680000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: (int)(sample_rate/192000)
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: center_frequency
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '.1'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: sabrSDR_sabr_source_1
  id: sabrSDR_sabr_source
  parameters:
    center_frequency: center_frequency
    gain: radio_gain
    gain_mode: gain_mode
    sample_rate: sample_rate
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [sabrSDR_sabr_source_1, '0', low_pass_filter_0, '0']
- [sabrSDR_sabr_source_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
