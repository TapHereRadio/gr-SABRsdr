options:
  parameters:
    author: sfriedman
    copyright: TapHere!
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: SABR GNURadio Demo
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '70000000'
    step: '100000'
    stop: '6000000000'
    value: '106700000'
    widget: counter
  states: {}
- name: gain_mode
  id: variable_qtgui_chooser
  parameters:
    label: Gain Mode
    label0: Manual Gain
    label1: Slow AGC
    label2: Fast AGC
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: radio_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '-10'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '[]'
    num_opts: '0'
    options: '[640000, 960000, 1000000, 1920000, 2000000, 3840000, 4000000, 6000000, 7680000, 8000000, 10000000, 14000000, 15360000, 16000000, 20000000, 24000000, 28000000, 30720000, 32000000, 36000000, 40000000, 44000000, 48000000, 52000000, 56000000, 60000000, 61440000]'
    orient: Qt.QHBoxLayout
    type: real
    value: '1920000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: center_frequency
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sabrSDR_sabr_source_0
  id: sabrSDR_sabr_source
  parameters:
    center_frequency: center_frequency
    gain: radio_gain
    gain_mode: gain_mode
    sample_rate: sample_rate
  states: {}

connections:
- [sabrSDR_sabr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
