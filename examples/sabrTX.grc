options:
  parameters:
    author: THR
    copyright: THR
    generate_options: qt_gui
    id: TransmitTest
    output_language: python
    title: SABR Transmit Test
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '70000000'
    step: '100000'
    stop: '6000000000'
    value: '2200000000'
    widget: counter
  states: {}
- name: default_samp
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["640000", "960000", "1000000", "1920000", "2000000", "3840000", "4000000", "6000000", "7680000", "8000000", "10000000", "14000000", "15360000", "16000000", "20000000", "24000000", "28000000", "30720000", "32000000", "36000000", "40000000", "44000000", "48000000", "52000000", "56000000", "60000000", "61440000"]'
    num_opts: '0'
    options: '[640000, 960000, 1000000, 1920000, 2000000, 3840000, 4000000, 6000000, 7680000, 8000000, 10000000, 14000000, 15360000, 16000000, 20000000, 24000000, 28000000, 30720000, 32000000, 36000000, 40000000, 44000000, 48000000, 52000000, 56000000, 60000000, 61440000]'
    orient: Qt.QHBoxLayout
    type: real
    value: default_samp
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    label: Attenuation
    orient: Qt.Horizontal
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1024 * 1.5
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/radio/Documents/CantinaBand48k.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: center_frequency
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.01'
    interp: (int)(sample_rate/quad_rate)
    taps: ''
    type: ccc
  states: {}
- name: sabrSDR_sabr_sink_0
  id: sabrSDR_sabr_sink
  parameters:
    attenuation: '0'
    center_frequency: center_frequency
    sample_rate: sample_rate
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', sabrSDR_sabr_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
