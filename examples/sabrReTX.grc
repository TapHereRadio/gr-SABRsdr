options:
  parameters:
    author: radio
    generate_options: qt_gui
    id: sabrReTX
    output_language: python
    title: SABR Retransmit
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '70000000'
    step: '100000'
    stop: '6000000000'
    value: '2200000000'
    widget: counter
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["640000", "960000", "1000000", "1920000", "2000000", "3840000", "4000000", "6000000", "7680000", "8000000", "10000000", "14000000", "15360000", "16000000", "20000000", "24000000", "28000000", "30720000", "32000000", "36000000", "40000000", "44000000", "48000000", "52000000", "56000000", "60000000", "61440000"]'
    num_opts: '0'
    options: '[640000, 960000, 1000000, 1920000, 2000000, 3840000, 4000000, 6000000, 7680000, 8000000, 10000000, 14000000, 15360000, 16000000, 20000000, 24000000, 28000000, 30720000, 32000000, 36000000, 40000000, 44000000, 48000000, 52000000, 56000000, 60000000, 61440000]'
    orient: Qt.QHBoxLayout
    type: real
    value: '7680000'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    label: Attenuation
    orient: Qt.Horizontal
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 512000 * 1.5
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/radio/RF38dB7_68.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: center_frequency
    fftsize: '512'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sabrSDR_sabr_sink_0
  id: sabrSDR_sabr_sink
  parameters:
    attenuation: '0'
    center_frequency: center_frequency
    sample_rate: sample_rate
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', sabrSDR_sabr_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
